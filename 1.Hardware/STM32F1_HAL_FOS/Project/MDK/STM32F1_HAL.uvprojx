# Keil uVision project STM32F1_HAL.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F1_HAL +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\System_LIB;..\..\HALLIB\STM32F1xx_HAL_Driver\Inc;..\..\Drive;..\..\SYSTEM;..\..\User;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\..\HALLIB;..\..\HALLIB\STM32F1xx_HAL_Driver\Src;..\..\..\STM32F1_HAL;..\..\APP;..\..\User;..\..\FreeRTOS\portable;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM3;..\..\FreeRTOS\portable\Keil;..\..\APP\FS_TASK
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Main
    ../../User/: Main.c main.h Timer.c Timer.h
  group HAL_LIB
    ../../HALLIB/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_dma.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim.c
  group System_LIB
    ../../System_LIB/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h core_cm3.h startup_stm32f103xe.s stm32f1xx_it.c system_stm32f1xx.c stm32f1xx_hal_msp.c
  group User
    ../../SYSTEM/sys/: sys.c
    ../../SYSTEM/delay/: delay.c
  group Drive
    ../../Drive/: C_USART.c C_USART.h C_Time.c C_Time.h WS2812B.c C_ADC.c C_ADC.h
  group App
    ../../APP/: C_Send.c C_Send.h
  group FreeRTOS
    ../../FreeRTOS/: queue.c list.c event_groups.c croutine.c tasks.c timers.c
    ../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../FreeRTOS/include/: FreeRTOSConfig.h FreeRTOS.h
  group FS_TASK
    ../../APP/FS_TASK/: A0_Task.c A0_Task.h B0_Task.c B0_Task.h
